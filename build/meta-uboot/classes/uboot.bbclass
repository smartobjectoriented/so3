# Copyright (c) 2025-2026 EDGEMTech SA

# Class for building U-boot in infrabase

IB_UBOOT_PATH = "${IB_DIR}/u-boot"

# Generated by the U-Boot build next to the real sources, so updiff would take
# them for new files. The entries named by path have a real namesake in the
# tree: arch/*/include/asm/config.h, arch/*/u-boot-spl.lds, arch/u-boot-elf.lds.

IB_UPDIFF_EXCLUDE ??= "u_boot_logo.S bmp_logo.h bmp_logo_data.h \
    helloworld_efi.S generated_defconfig include/config.h \
    image.map keep-syms-lto.c libfdt.i libfdt.py libfdt_wrap.c \
    nxp.imx8mimage.cfg.section.* flash.bin.inputs.sha256 \
    spl/u-boot-spl.* /u-boot-elf.lds"


