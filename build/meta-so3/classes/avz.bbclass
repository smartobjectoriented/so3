# Copyright (c) 2025-2026 EDGEMTech SA

# Class for building the AVZ hypervisor in infrabase

IB_AVZ_PATH = "${IB_DIR}/avz"
