# Copyright (c) 2025-2026 EDGEMTech SA

# Class for building SO3 in infrabase

IB_SO3_PATH = "${IB_DIR}/so3"

