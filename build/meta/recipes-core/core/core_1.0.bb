# Copyright (c) 2025-2026 EDGEMTech SA

DESCRIPTION = "Core recipe"

