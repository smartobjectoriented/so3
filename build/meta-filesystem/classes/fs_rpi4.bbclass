
# Specific task description for formatting
# the storage of Raspberry Pi 4 (32-bit) (rpi4) platform

inherit fs_arm_common
