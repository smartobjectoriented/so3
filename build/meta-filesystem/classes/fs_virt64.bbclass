# Copyright (c) 2025-2026 EDGEMTech SA

# Specific task description for formatting
# the storage of virt64 platform

inherit fs_arm_common
